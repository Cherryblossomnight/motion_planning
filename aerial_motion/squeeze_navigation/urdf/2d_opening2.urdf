Commit message: merge

File: aerial_motion/squeeze_navigation/urdf/2d_opening2.urdf (robot description, URDF)
Before this commit: robot opening, 0 links, 3 joints
Joints:
- removed joint frame_joint2
- removed joint frame_joint3
